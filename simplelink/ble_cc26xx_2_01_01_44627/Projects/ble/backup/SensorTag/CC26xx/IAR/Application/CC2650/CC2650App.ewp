# IAR project CC2650App.ewp, settings and files
configuration FlashOnlyOAD (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: POWER_SAVING; GATT_TI_UUID_128_BIT; FEATURE_REGISTER_SERVICE; FEATURE_OAD; FACTORY_IMAGE; USE_ICALL; TI_DRIVERS_PIN_INCLUDED; TI_DRIVERS_I2C_INCLUDED; TI_DRIVERS_SPI_INCLUDED; HEAPMGR_SIZE=2872; ICALL_MAX_NUM_TASKS=8; ICALL_MAX_NUM_ENTITIES=11; CC26XXWARE; CC26XX; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f ..\..\..\..\..\..\..\Projects\ble\config\buildComponents.opt; -f configPkg\compiler.opt.defs; -f ..\..\Config\IAR-Boundary.bdef
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; ../../../../../../../Projects/ble/Include; ../../../../../../../Projects/ble/ICall/Include; ../../../../../../../Projects/ble/Profiles/Roles/CC26xx; ../../../../../../../Projects/ble/Profiles/Roles; ../../../../../../../Projects/ble/Profiles/Keys; ../../../../../../../Projects/ble/Profiles/DevInfo; ../../../../../../../Projects/ble/Profiles/SensorProfile/cc26xx; ../../../../../../../Projects/ble/Profiles/OAD/cc26xxST; ../../../../../../../Projects/ble/common/cc26xx; ../../../../../../../Components/applib/heap; ../../../../../../../Components/ble/hci; ../../../../../../../Components/ble/controller/CC26xx/include; ../../../../../../../Components/ble/host; ../../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../../Components/hal/include; ../../../../../../../Components/osal/include; ../../../../../../../Components/services/sdata; ../../../../../../../Components/services/saddr; ../../../../../../../Components/icall/include; ../../../../../../../Components/icall/ports/tirtos; ../../../../../../../Components/ble/include; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; ../../../Source/Application/Board_patch/interfaces; ../../../Source/Application/Board_patch/devices; ../../../Source/Application/Board_patch/CC26XXST_0120
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SensorTagAppFlashOnlyOAD.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: SensorTagAppFlashOnlyOAD.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1
  ILINK.IlinkIcfFile: cc26xx_ble_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd; -f ..\..\Config\IAR-Boundary.xcl
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashOnly (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  ICCARM.CCDefines: POWER_SAVING; GATT_TI_UUID_128_BIT; FEATURE_REGISTER_SERVICE; USE_ICALL; TI_DRIVERS_PIN_INCLUDED; TI_DRIVERS_I2C_INCLUDED; TI_DRIVERS_SPI_INCLUDED; HEAPMGR_SIZE=2872; ICALL_MAX_NUM_TASKS=8; ICALL_MAX_NUM_ENTITIES=11; CC26XXWARE; CC26XX; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  group Application
    ../../../Source/Application/: SensorTag.c sensorTag.h SensorTag_Bar.c SensorTag_Bar.h SensorTag_ConnCtrl.c SensorTag_ConnCtrl.h SensorTag_Hum.c SensorTag_Hum.h SensorTag_IO.c SensorTag_IO.h SensorTag_Keys.c SensorTag_Keys.h SensorTag_Mov.c SensorTag_Mov.h SensorTag_Opt.c SensorTag_Opt.h SensorTag_Revision.h SensorTag_Tmp.c SensorTag_Tmp.h
    ../../../../../common/cc26xx/: util.c util.h
  group Board/Devices
    ../../../Source/Application/Board_patch/Devices/: ext_flash.c ext_flash.h sensor_bmp280.c sensor_bmp280.h sensor_hdc1000.c sensor_hdc1000.h sensor_mpu9250.c sensor_mpu9250.h sensor_opt3001.c sensor_opt3001.h sensor_tmp007.c sensor_tmp007.h
  group Board/Interfaces
    ../../../Source/Application/Board_patch/Interfaces/: bsp_i2c.c bsp_i2c.h bsp_spi.c bsp_spi.h sensor.c sensor.h
  group Drivers/I2C
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: I2C.c I2C.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/i2c/: I2CCC26XX.c I2CCC26XX.h
    ../../../../../../../../../tirtos_simplelink_2_13_00_06/: packages
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    ../../../../../../../Components/applib/heap/: heapmgr.h
    ../../../../../../../Components/icall/ports/tirtos/: ICall.c ICallCC2650.c ICallPlatform.h
    ../../../../../../../Components/icall/include/: ICall.h
    ../../../../../../../Components/hal/target/CC2650TIRTOS/: ICallAddrs.h
  group ICallBLE
    ../../../../../ICall/Application/: bleUserConfig.c ICallBleAPI.c
    ../../../../../ICall/Include/: bleUserConfig.h ICallBleAPIMSG.h
  group Include
    ../../../../../../../Components/ble/include/: gap.h gatt.h hci.h
    ../../../../../Profiles/Roles/: gapbondmgr.h
    ../../../../../Include/: gapgattserver.h
    ../../../../../../../Components/osal/include/: osal_snv.h
  group PROFILES
    ../../../../../Profiles/SensorProfile/CC26xx/: barometerservice.c barometerservice.h ccservice.c ccservice.h humidityservice.c humidityservice.h ioservice.c ioservice.h irtempservice.c irtempservice.h movementservice.c movementservice.h opticservice.c opticservice.h registerservice.c registerservice.h st_util.c st_util.h
    ../../../../../Profiles/DevInfo/CC26xx/: devinfoservice.c
    ../../../../../Profiles/DevInfo/: devinfoservice.h
    ../../../Source/Application/: ext_flash_layout.h
    ../../../../../Include/: gatt_profile_uuid.h
    ../../../../../../../Components/ble/host/: gatt_uuid.c
    ../../../../../../../Components/ble/include/: gatt_uuid.h
    ../../../../../Profiles/GATT/: gattservapp_util.c
    ../../../../../Profiles/OAD/CC26xxST/: oad.c oad.h oad_target.h oad_target_externalFlash.c
    ../../../../../Profiles/Roles/CC26xx/: peripheral.c peripheral.h
    ../../../../../Profiles/Keys/CC26xx/: simplekeys.c
    ../../../../../Profiles/Keys/: simplekeys.h
  group Startup
    ../../../Source/Application/Board_patch/: Board.c
    ../../Config/: ccfg_appBLE.c
    ../../../Source/Application/: main.c
  group TOOLS
    ../../Config/: appBLE.cfg
    ./: cc26xx_ble_app.icf
