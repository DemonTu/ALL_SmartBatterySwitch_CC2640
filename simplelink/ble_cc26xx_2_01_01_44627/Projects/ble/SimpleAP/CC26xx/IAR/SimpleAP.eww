<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\util\BIM_extflash\CC26xx\IAR\BIM_extflash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Application\CC2640\CC2640App.ewp</path>
  </project>
  <batchBuild/>
</workspace>


